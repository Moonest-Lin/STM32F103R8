# Keil uVision project project.uvprojx, settings and files
target STM32F103R8 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10x_MD,USE_STDPERIPH_DRIVER
  c include: .\Hardware;.\Library;.\Startup;.\System;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Startup/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: AD.c AD.h BCD.c BCD.h delay.c delay.h DMA_.c DMA_.h ExtTimer.c ExtTimer.h IC.c IC.h IntTimer.c IntTimer.h PWM.c PWM.h PWMI.c PWMI.h USART.c USART.h
  group Hardware
    ./Hardware/: Buzzer.c Buzzer.h CountSensor.c CountSensor.h Encoder.c Encoder.h Key.c Key.h LED.c LED.h LightSensor.c LightSensor.h Motor.c Motor.h OLED.c OLED.h OLED_Font.h Servo.c Servo.h TIMEncoder.c TIMEncoder.h Relay.c Relay.h DHT11.c DHT11.h W25Q16.c W25Q16.h
  group User
    ./User/: GPIO.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
